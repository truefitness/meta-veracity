THISDIR := "${@os.path.dirname(bb.data.getVar('FILE', d, True))}"
FILESPATH =. "${@base_set_filespath(["${THISDIR}/${PN}"], d)}:"

#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


