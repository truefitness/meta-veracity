# Add config option to build vaapisink/GL

EXTRA_OECONF += "--enable-vaapisink-glx"
