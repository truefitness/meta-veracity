RRECOMMENDS_task-core-tools-profile_append_veracity = " systemtap"
RRECOMMENDS_task-core-tools-profile_append_veracity-nopvr = " systemtap"

