# Add True Logo splash screen image

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
