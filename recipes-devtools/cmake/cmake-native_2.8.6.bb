require cmake.inc
inherit native

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2147da452fd9212bb9b4542a9eee9d5b"
SRC_URI[sha256sum] = "e6999b81ac367d85ffb0f69b6c4a0ef96f95dc154efd3592f9cfebacdf75728e"
