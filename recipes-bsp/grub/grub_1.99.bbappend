# Add our 40_custom grub menu file

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
